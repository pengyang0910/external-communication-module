# Keil uVision project GD32F503.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: GD32F503CE GigaDevice
  pack: GigaDevice.GD32F50x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: GD32F503
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F50X,GD32F503
  c include: .\User
  asm define: GD32F50X,GD32F503
  asm include: .\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c bsp_delay.c bsp_uart.c bsp_gpio.c bsp_adc.c bsp_eeprom.c bsp_can.c bsp_spi_ch394.c
  group Drivers
    ./Drivers/: gd32f50x_spi.c gd32f50x_can.c gd32f50x_adc.c gd32f50x_fmc.c gd32f50x_dbg.c
software components: CMSIS:CORE 6.2.0, Device:GD32F50x_StdPeripherals:GPIO 1.0.0, Device:GD32F50x_StdPeripherals:MISC 1.0.0, Device:GD32F50x_StdPeripherals:PMU 1.0.0, Device:GD32F50x_StdPeripherals:RCU 1.0.0, Device:GD32F50x_StdPeripherals:USART 1.0.0, Device:GD32F50x_libopt 1.0.0, Device:Startup 1.0.0
